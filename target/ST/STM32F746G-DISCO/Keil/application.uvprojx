# Keil uVision project application.uvprojx, settings and files
target STM32F746G-DISCO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --only=ExtFlashSection --bin --output=binary .\Flash\application.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: ST STM32F756xx USE_FREERTOS_8 USE_OS_SYSTICK USE_STM32746G_DISCOVERY USE_BPP=16
  c include: ..\..\..\..\gui\include;..\..\..\..\target\include;..\..\..\..\platform\os;..\..\..\..\generated\fonts\include;..\..\..\..\generated\images\include;..\..\..\..\generated\texts\include;..\..\..\..\generated\gui_generated\include;..\..\..\..\..\..\TouchGFX\touchgfx\framework\include;..\..\..\..\..\..\TouchGFX\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS;..\..\..\..\..\..\TouchGFX\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx;..\..\..\..\..\..\TouchGFX\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\CMSIS;..\..\..\..\..\..\TouchGFX\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\STM32F7xx_HAL_Driver;..\..\..\..\..\..\TouchGFX\touchgfx\board\ST\STM32F746G-DISCO\include;..\..\..\..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\include\vendor;..\..\..\..\..\..\TouchGFX\touchgfx\board\ST\STM32F746G-DISCO\source\vendor\STM32746G-Discovery;..\..\..\..\..\..\TouchGFX\touchgfx\os\FreeRTOS8.2.0\Source\include;..\..\..\..\..\..\TouchGFX\touchgfx\os\FreeRTOS8.2.0\Source\portable\RVDS\ST_CM7;..\..\..\..\Hardware\Inc
  asm include: .\os\FreeRTOSV8.2.0\FreeRTOS\Source\include;.\os\FreeRTOSV8.2.0\FreeRTOS\Source\portable\RVDS\ST_CM7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Flash_QSPI.sct
  group Startup
    ../../../: main.cpp
    ../../../../../../TouchGFX/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/CMSIS/: system_stm32f7xx.c
    ../../../../../../TouchGFX/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/Keil/: startup_stm32f746xx.s
  group Gui
    ../../../../gui/src/datetimesettingsscreen_screen/: dateTimeSettingsScreenPresenter.cpp dateTimeSettingsScreenView.cpp
    ../../../../gui/src/daynightsettingsscreen_screen/: dayNightSettingsScreenPresenter.cpp dayNightSettingsScreenView.cpp
    ../../../../gui/src/common/: FrontendApplication.cpp
    ../../../../gui/src/mainscreen_screen/: mainScreenPresenter.cpp mainScreenView.cpp
    ../../../../gui/src/model/: Model.cpp
    ../../../../gui/src/opconfigsettingsscreen_screen/: opConfigSettingsScreenPresenter.cpp opConfigSettingsScreenView.cpp
    ../../../../gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
    ../../../../gui/src/settingsscreen_screen/: settingsScreenPresenter.cpp settingsScreenView.cpp
    ../../../../gui/src/temphumisettingsscreen_screen/: tempHumiSettingsScreenPresenter.cpp tempHumiSettingsScreenView.cpp
  group GuiGenerated
    ../../../../generated/gui_generated/src/datetimesettingsscreen_screen/: dateTimeSettingsScreenViewBase.cpp
    ../../../../generated/gui_generated/src/daynightsettingsscreen_screen/: dayNightSettingsScreenViewBase.cpp
    ../../../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../../../../generated/gui_generated/src/mainscreen_screen/: mainScreenViewBase.cpp
    ../../../../generated/gui_generated/src/opconfigsettingsscreen_screen/: opConfigSettingsScreenViewBase.cpp
    ../../../../generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
    ../../../../generated/gui_generated/src/settingsscreen_screen/: settingsScreenViewBase.cpp
    ../../../../generated/gui_generated/src/temphumisettingsscreen_screen/: tempHumiSettingsScreenViewBase.cpp
  group Generated
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_segoeui_17_8bpp.cpp Font_segoeui_18_8bpp.cpp Font_segoeui_28_8bpp.cpp Font_segoeui_40_8bpp.cpp Font_segoeui_67_4bpp.cpp Font_verdana_12_4bpp.cpp Font_verdana_17_8bpp.cpp Font_verdana_34_4bpp.cpp Font_verdana_46_4bpp.cpp FontGetters.cpp Kerning_segoeui_17_8bpp.cpp Kerning_segoeui_18_8bpp.cpp Kerning_segoeui_28_8bpp.cpp Kerning_segoeui_40_8bpp.cpp Kerning_segoeui_67_4bpp.cpp Kerning_verdana_12_4bpp.cpp Kerning_verdana_17_8bpp.cpp Kerning_verdana_34_4bpp.cpp Kerning_verdana_46_4bpp.cpp Table_segoeui_17_8bpp.cpp Table_segoeui_18_8bpp.cpp Table_segoeui_28_8bpp.cpp Table_segoeui_40_8bpp.cpp Table_segoeui_67_4bpp.cpp Table_verdana_12_4bpp.cpp Table_verdana_17_8bpp.cpp Table_verdana_34_4bpp.cpp Table_verdana_46_4bpp.cpp
    ../../../../generated/images/src/: background.cpp BitmapDatabase.cpp
    ../../../../generated/images/src/__designer/: Dark_Buttons_Round_Edge_icon_button.cpp Dark_Buttons_Round_Edge_icon_button_pressed.cpp Dark_Buttons_Round_Edge_large.cpp Dark_Buttons_Round_Edge_large_pressed.cpp Dark_Icons_Back_arrow_32.cpp Dark_Icons_Down_arrow_32.cpp Dark_Icons_Home_32.cpp Dark_Icons_Info_32.cpp Dark_Icons_Power_32.cpp Dark_Icons_Settings_32.cpp Dark_Icons_Up_arrow_32.cpp Dark_Slider_Vertical_Small_Indicators_Slider3_Vertical_Round_nob.cpp Dark_Slider_Vertical_Small_Slider3_Vertical_Round_back.cpp Dark_Slider_Vertical_Small_Slider3_Vertical_Round_fill.cpp Dark_Togglebars_Toggle_round_small_button_Off.cpp Dark_Togglebars_Toggle_round_small_button_On.cpp Dark_Togglebars_Toggle_small_button_Off.cpp Dark_Togglebars_Toggle_small_button_On.cpp
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFXHAL
    ../../../../../../TouchGFX/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
    ../../../../../../TouchGFX/touchgfx/board/ST/STM32F746G-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../TouchGFX/touchgfx/board/ST/STM32F746G-DISCO/source/bsp/: STM32F7Instrumentation.cpp STM32F746GTouchController.cpp
    ../../../../../../TouchGFX/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c stm32746g_discovery_qspi.c
  group OS
    ../../../../../../TouchGFX/touchgfx/os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../../../../../../TouchGFX/touchgfx/os/FreeRTOS8.2.0/: OSWrappers.cpp
    ../../../../../../TouchGFX/touchgfx/os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7/: port.c
    ../../../../../../TouchGFX/touchgfx/os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
  group HAL
    ../../../../../../TouchGFX/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/Components/ft5336/: ft5336.c
    ../../../../../../TouchGFX/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c
  group Lib
    ../../../../../../TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group User
    ../../../../Hardware/Src/: rtc.c gpio.c sensor.cpp opSocket.cpp actuator.cpp clockTime.cpp
