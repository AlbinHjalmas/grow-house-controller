# Keil uVision project mx.uvprojx, settings and files
target mx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: mx
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;          C:/Users/Hjalm/STM32Cube/Repository/STM32Cube_FW_F7_V1.6.1/Drivers/STM32F7xx_HAL_Driver/Inc;          C:/Users/Hjalm/STM32Cube/Repository/STM32Cube_FW_F7_V1.6.1/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;          C:/Users/Hjalm/STM32Cube/Repository/STM32Cube_FW_F7_V1.6.1/Drivers/CMSIS/Device/ST/STM32F7xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f7xx_it.c stm32f7xx_hal_msp.c rtc.c main.c gpio.c
  group Drivers/STM32F7xx_HAL_Driver
    C:/Users/Hjalm/STM32Cube/Repository/STM32Cube_FW_F7_V1.6.1/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.2.0
